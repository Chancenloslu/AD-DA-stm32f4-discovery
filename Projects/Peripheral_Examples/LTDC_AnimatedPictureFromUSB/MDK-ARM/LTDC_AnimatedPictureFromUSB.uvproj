# Keil uVision project LTDC_AnimatedPictureFromUSB.uvproj, settings and files
target LTDC_AnimatedPictureFromUSB (6180000::V6.18::ARMCLANG)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: LTDC_AnimatedPictureFromUSB
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_EMBEDDED_PHY,
  c include: .\..\;.\..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;.\..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;.\..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;.\..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\..\Utilities\STM32F429I-Discovery;.\..\..\..\..\Utilities\Common;.\..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./../: main.c stm32fxxx_it.c usb_bsp.c usbh_usr.c
  group FAT_FS
    ./../: fattime.c
    ./../../../../Utilities/Third_Party/fat_fs/src/: ff.c
  group STM32_EVAL
    ./../../../../Utilities/Common/: lcd_log.c
  group STM32F4xx
    ./../../../../Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
    ./../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
    ./../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ./../: system_stm32f4xx.c
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_spi.c stm32f4xx_tim.c
  group USB_Host
    ./../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ./../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
